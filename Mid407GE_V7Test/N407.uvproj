# Keil uVision project N407.uvproj, settings and files
target STM32F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: N407 +hex
  c flags: Optim=1 wLevel=2
  c include: .\LIB;.\INC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./SRC/: Main.c TcpUdp.c AppLayer.c EtherCmd.cpp APP_CAN.cpp Dev.Cpp Chan.Cpp ChanEther.cpp ParallelChan.Cpp SubChan.Cpp
  group Configuration Files
    ./SRC/: RTX_CAN.c Net_Config.c RTX_Config.c Sys_Config.cpp
  group Library
    ./LIB/: TCP_CM3.lib
  group Drivers
    ./SRC/: startup_stm32f4xx.s system_stm32f4xx.c ETH_STM32F4xx.c CAN_STM32F40x.c
  group Interface
    ./SRC/: LED.c SPI.c GPIO.c Timer.c WatchDog.c UartSimCan.c
  group Abstract
    ./: READ ME.TXT
